# Keil uVision project temperature.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5616AD Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: temperature +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\mcu_sdk
  group Source Group 1
    ./: STARTUP.A51
  group mcu_sdk
    ./mcu_sdk/: mcu_api.c protocol.c system.c
  group APP
    ./APP/: LCD_init.c main.c myiic.c USART.c User_SHT30.c
